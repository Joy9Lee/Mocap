<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app\app.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\TI\CC3200SDK_1.1.0\cc3200-sdk\example\deepsleep_nw\ewarm\deepsleep_nw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3200-SDK\driverlib\ewarm\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3200-SDK\oslib\ewarm\oslib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3200-SDK\simplelink\ewarm\simplelink.ewp</path>
  </project>
  <batchBuild/>
</workspace>


