# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: ..\CC3200-SDK\inc; ..\CC3200-SDK\driverlib; ..\CC3200-SDK\oslib; ..\CC3200-SDK\simplelink\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\CC3200-SDK\driverlib\ewarm\Release\Exe\driverlib.a; ..\CC3200-SDK\oslib\ewarm\free_rtos\Exe\free_rtos.a; ..\CC3200-SDK\simplelink\ewarm\OS\Exe\simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cc_hal_gpio.c cc_hal_pm.c cc_hal_pwm.c cc_hal_spi.c cc_hal_timer.c cc_hal_wifi.c cc_pinmux.c cc_utils.c free_rtos_hook.c main.c mc_hal_ads129x.c mc_hal_led.c mc_hal_mpu9250.c mc_hal_sw.c mc_os.c mc_process.c mc_profiles.c mc_protocol.c startup_ewarm.c
